Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: a15d7124-8e8d-4343-8dfc-4835a82e79a7, NumberOfSaves: 4], CoordinateReference [CoordinateBase: Coordenadas compartidas, ProjectSite: Interna]
Time: 2024-03-04T15:58:27
Written by: ODA IFC SDK 22.8
Made in: 22.1.50.17 - Exporter 22.6.2.0 - IU alternativa 22.6.2.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 0

# IfcBuildingStorey: Nivel:A- Nivell (4)
Name | LongName | Elevation (m)
PS1- Gimnàs | PS1- Gimnàs | -5.45
PS1- Vestuari | PS1- Vestuari | -4.46
P0- Escola | P0- Escola | 0
PC- Coberta STR | PC- Coberta STR | 3.4
